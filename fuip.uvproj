# Keil uVision project fuip.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: clientENJ +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\mcu;.\enc28j60;.\fu_ip
  group Source Group 1
    ./: STARTUP.A51 fu_main.c
  group mcu
    ./mcu/: spi.c Uart.c timer.c
  group enc28j60
    ./enc28j60/: enc28j60.c
  group fu_ip
    ./fu_ip/: fu_app.c fu_arp.c fu_config.c fu_dhcp.c fu_enthernet.c fu_http.c fu_icmp.c fu_ip.c fu_receive.c fu_send.c fu_tcp.c fu_udp.c fu_dns.c
